## faultmin_SD805/Kconfig
```kconfig
config CONFIG_GLITCHMIN
	gtristate "Software Fault Attack Profiling Module"
	default m
	help
	  say M to compile it as a module
```
